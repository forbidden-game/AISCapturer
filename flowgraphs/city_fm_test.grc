options:
  parameters:
    category: Custom
    description: City RF test (FM broadcast)
    generate_options: qt_gui
    id: city_fm_test
    output_language: python
    title: City FM Test (FM Broadcast)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: chan_rate
  id: variable
  parameters:
    value: samp_rate/decim
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RF Gain (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '20'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Center Freq (MHz)
    orient: Qt.Horizontal
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 100e6
  states: {}
- name: fm_bw
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: fm_trans
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: fm_taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, fm_bw, fm_trans)
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    stream_args: '""'
    sync: none
    type: fc32
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decim
    samp_rate: samp_rate
    taps: fm_taps
    type: ccf
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decim
    quad_rate: chan_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '""'
    samp_rate: audio_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    gui_hint: 0,1,1,1
    name: '"Wideband Spectrum"'
    tr_delay: '0'
    tr_slope: qtgui.TRIG_SLOPE_POS
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    autoscale: 'False'
    average: '0.2'
    bw: samp_rate
    color1: '"blue"'
    ctrlpanel: 'False'
    fc: center_freq
    fftsize: '2048'
    gui_hint: 1,1,1,1
    label: Relative Gain
    name: '"Wideband Waterfall"'
    tr_chan: '0'
    tr_delay: '0'
    tr_level: '0.0'
    tr_mode: qtgui.TRIG_MODE_FREE
    tr_slope: qtgui.TRIG_SLOPE_POS
    tr_tag: '""'
    type: complex
    units: dB
    ymin: '-140'
    ymax: '10'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: chan_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,2,1,1
    name: '"FM Baseband Spectrum"'
    tr_delay: '0'
    tr_slope: qtgui.TRIG_SLOPE_POS
    type: complex
  states: {}

connections:
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1

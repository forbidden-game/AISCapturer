options:
  parameters:
    category: Custom
    description: AIS wideband capture + split + verify
    generate_options: qt_gui
    id: ais_collect_wideband
    output_language: python
    title: AIS Collect Wideband
  states: {}

blocks:
- name: ais1_offset
  id: variable
  parameters:
    value: '-25e3'
  states: {}
- name: ais2_offset
  id: variable
  parameters:
    value: 25e3
  states: {}
- name: ais_demod_rate
  id: variable
  parameters:
    value: ais_sym_rate*ais_sps
  states: {}
- name: ais_sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: ais_sym_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: ant
  id: variable
  parameters:
    value: '"RX2"'
  states: {}
- name: base_name_ais1
  id: variable
  parameters:
    value: '"AIS1_200kSps"'
  states: {}
- name: base_name_ais2
  id: variable
  parameters:
    value: '"AIS2_200kSps"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 162e6
  states: {}
- name: chan_bw
  id: variable
  parameters:
    value: 12.5e3
  states: {}
- name: chan_rate
  id: variable
  parameters:
    value: samp_rate/decim
  states: {}
- name: chan_trans
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: out_dir
  id: variable
  parameters:
    value: '"/home/pan/expri/gnuradio/collect_AIS/captures"'
  states: {}
- name: out_file_ais1
  id: variable
  parameters:
    value: out_dir + "/" + base_name_ais1 + "_" + time.strftime("%Y%m%d_%H%M%S") + ".sigmf-data"
  states: {}
- name: out_file_ais2
  id: variable
  parameters:
    value: out_dir + "/" + base_name_ais2 + "_" + time.strftime("%Y%m%d_%H%M%S") + ".sigmf-data"
  states: {}
- name: resamp_decim
  id: variable
  parameters:
    value: '50'
  states: {}
- name: resamp_interp
  id: variable
  parameters:
    value: '12'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samples_per_file
  id: variable
  parameters:
    value: int(samp_rate * seg_secs)
  states: {}
- name: seg_secs
  id: variable
  parameters:
    value: '10'
  states: {}
- name: xlating_taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, chan_bw, chan_trans)
  states: {}
- name: ais_demod_0
  id: ais_demod
  parameters:
    bits_per_sec: ais_sym_rate
    clockrec_gain: '0.04'
    fftlen: '1024'
    omega_relative_limit: '0.01'
    samples_per_symbol: ais_sps
  states: {}
- name: ais_demod_1
  id: ais_demod
  parameters:
    bits_per_sec: ais_sym_rate
    clockrec_gain: '0.04'
    fftlen: '1024'
    omega_relative_limit: '0.01'
    samples_per_symbol: ais_sps
  states: {}
- name: ais_pdu_to_nmea_0
  id: ais_pdu_to_nmea
  parameters:
    designator: '"A"'
  states: {}
- name: ais_pdu_to_nmea_1
  id: ais_pdu_to_nmea
  parameters:
    designator: '"B"'
  states: {}
- name: blocks_file_sink_ais1
  id: blocks_file_sink
  parameters:
    file: out_file_ais1
    type: complex
  states: {}
- name: blocks_file_sink_ais2
  id: blocks_file_sink
  parameters:
    file: out_file_ais2
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_stats_ais1
  id: blocks_throttle
  parameters:
    samples_per_second: '2'
    type: float
  states: {}
- name: blocks_throttle_stats_ais2
  id: blocks_throttle
  parameters:
    samples_per_second: '2'
    type: float
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '64'
    min: '11'
  states: {}
- name: digital_hdlc_deframer_bp_1
  id: digital_hdlc_deframer_bp
  parameters:
    max: '64'
    min: '11'
  states: {}
- name: epy_block_stats_ais1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__ will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      LABEL = "AIS1"

      class PduStats(gr.sync_block):
          """
          Count PDUs and report CRC OK FPS
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PDU Stats',
                  in_sig=None,
                  out_sig=[np.float32]
              )
              self._count = 0
              self._total = 0
              self._rate = 0.0
              self._t0 = time.time()
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self._handle_msg)

          def _handle_msg(self, msg):
              self._count += 1
              self._total += 1

          def work(self, input_items, output_items):
              now = time.time()
              dt = now - self._t0
              if dt >= 1.0:
                  if dt > 0:
                      self._rate = self._count / dt
                  else:
                      self._rate = 0.0
                  print(f"[{LABEL}] CRC_OK_FPS={self._rate:.2f} TOTAL={self._total}")
                  self._count = 0
                  self._t0 = now
              output_items[0][:] = self._rate
              return len(output_items[0])
    comment: AIS1 PDU stats
  states: {}
- name: epy_block_stats_ais2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__ will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      LABEL = "AIS2"

      class PduStats(gr.sync_block):
          """
          Count PDUs and report CRC OK FPS
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PDU Stats',
                  in_sig=None,
                  out_sig=[np.float32]
              )
              self._count = 0
              self._total = 0
              self._rate = 0.0
              self._t0 = time.time()
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self._handle_msg)

          def _handle_msg(self, msg):
              self._count += 1
              self._total += 1

          def work(self, input_items, output_items):
              now = time.time()
              dt = now - self._t0
              if dt >= 1.0:
                  if dt > 0:
                      self._rate = self._count / dt
                  else:
                      self._rate = 0.0
                  print(f"[{LABEL}] CRC_OK_FPS={self._rate:.2f} TOTAL={self._total}")
                  self._count = 0
                  self._t0 = now
              output_items[0][:] = self._rate
              return len(output_items[0])
    comment: AIS2 PDU stats
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ais1_offset
    decim: decim
    samp_rate: samp_rate
    taps: xlating_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ais2_offset
    decim: decim
    samp_rate: samp_rate
    taps: xlating_taps
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    gui_hint: 0,0,1,1
    name: '"Wideband Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: chan_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,1,1
    name: '"AIS1 Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: chan_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,1
    name: '"AIS2 Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_ais1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: AIS1 CRC_OK FPS
    max: '50'
    min: '0'
    name: '"AIS1 CRC OK FPS"'
    type: float
    unit1: fps
    update_time: '0.5'
  states: {}
- name: qtgui_number_sink_ais2
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: AIS2 CRC_OK FPS
    max: '50'
    min: '0'
    name: '"AIS2 CRC OK FPS"'
    type: float
    unit1: fps
    update_time: '0.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: ''
    label2: ''
    name: '"Wideband Time"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    gui_hint: 0,1,1,1
    name: '"Wideband Waterfall"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: resamp_decim
    fbw: '0.4'
    interp: resamp_interp
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: resamp_decim
    fbw: '0.4'
    interp: resamp_interp
    taps: ''
    type: ccc
  states: {}
- name: rotate_files
  id: snippet
  parameters:
    code: |
      import os, time, threading, json


      def _write_sigmf_meta(data_path, center_freq_hz):
          meta_path = data_path.replace('.sigmf-data', '.sigmf-meta')
          now_iso = time.strftime("%Y-%m-%dT%H:%M:%SZ", time.gmtime())
          meta = {
              "global": {
                  "core:version": "1.0.0",
                  "core:datatype": "cf32_le",
                  "core:sample_rate": float(self.chan_rate),
                  "core:description": "AIS baseband (post freq-xlating), 200 kSps"
              },
              "captures": [
                  {
                      "core:sample_start": 0,
                      "core:frequency": float(center_freq_hz),
                      "core:datetime": now_iso
                  }
              ],
              "annotations": []
          }
          with open(meta_path, "w", encoding="utf-8") as f:
              json.dump(meta, f, indent=2)


      def _rotate_files():
          os.makedirs(self.out_dir, exist_ok=True)
          while True:
              ts = time.strftime("%Y%m%d_%H%M%S")
              fname1 = os.path.join(self.out_dir, f"{self.base_name_ais1}_{ts}.sigmf-data")
              fname2 = os.path.join(self.out_dir, f"{self.base_name_ais2}_{ts}.sigmf-data")
              self.set_out_file_ais1(fname1)
              self.set_out_file_ais2(fname2)
              _write_sigmf_meta(fname1, 161975000.0)
              _write_sigmf_meta(fname2, 162025000.0)
              
              time.sleep(self.seg_secs)

      # start immediately
      _rotate_thread = threading.Thread(target=_rotate_files, daemon=True)
      _rotate_thread.start()
    comment: Rotate capture file every seg_secs
    priority: '200'
    section: main_after_start
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ant
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: samp_rate
    stream_args: '""'
    sync: none
    type: fc32
  states: {}

connections:
- [ais_demod_0, '0', digital_hdlc_deframer_bp_0, '0']
- [ais_demod_1, '0', digital_hdlc_deframer_bp_1, '0']
- [ais_pdu_to_nmea_0, out, blocks_message_debug_0, print]
- [ais_pdu_to_nmea_1, out, blocks_message_debug_1, print]
- [blocks_throttle_stats_ais1, '0', qtgui_number_sink_ais1, '0']
- [blocks_throttle_stats_ais2, '0', qtgui_number_sink_ais2, '0']
- [digital_hdlc_deframer_bp_0, out, ais_pdu_to_nmea_0, to_nmea]
- [digital_hdlc_deframer_bp_0, out, epy_block_stats_ais1, in]
- [digital_hdlc_deframer_bp_1, out, ais_pdu_to_nmea_1, to_nmea]
- [digital_hdlc_deframer_bp_1, out, epy_block_stats_ais2, in]
- [epy_block_stats_ais1, '0', blocks_throttle_stats_ais1, '0']
- [epy_block_stats_ais2, '0', blocks_throttle_stats_ais2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_ais1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', blocks_file_sink_ais2, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_freq_sink_x_2, '0']
- [freq_xlating_fir_filter_xxx_1, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', ais_demod_0, '0']
- [rational_resampler_xxx_1, '0', ais_demod_1, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
